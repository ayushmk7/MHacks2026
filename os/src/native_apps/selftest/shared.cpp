// src/native_apps/selftest/shared.cpp
#include "shared.h"

#include <stdio.h>
#include <string.h>

#include "../../apps/app_store.h"      // mounted(), usedBytes(), totalBytes()
#include "../../net/wifi_mgr.h"
#include "../../vk/core/fileio.h"

namespace selftest {

namespace {
constexpr char TEMP_FILE[] = "/vk/selftest.tmp";

// RFC 8032, section 7.1.
const uint8_t T1_KEY[32] = {
    0xd7, 0x5a, 0x98, 0x01, 0x82, 0xb1, 0x0a, 0xb7, 0xd5, 0x4b, 0xfe, 0xd3, 0xc9, 0x64, 0x07, 0x3a,
    0x0e, 0xe1, 0x72, 0xf3, 0xda, 0xa6, 0x23, 0x25, 0xaf, 0x02, 0x1a, 0x68, 0xf7, 0x07, 0x51, 0x1a,
};
const uint8_t T1_SIG[64] = {
    0xe5, 0x56, 0x43, 0x00, 0xc3, 0x60, 0xac, 0x72, 0x90, 0x86, 0xe2, 0xcc, 0x80, 0x6e, 0x82, 0x8a,
    0x84, 0x87, 0x7f, 0x1e, 0xb8, 0xe5, 0xd9, 0x74, 0xd8, 0x73, 0xe0, 0x65, 0x22, 0x49, 0x01, 0x55,
    0x5f, 0xb8, 0x82, 0x15, 0x90, 0xa3, 0x3b, 0xac, 0xc6, 0x1e, 0x39, 0x70, 0x1c, 0xf9, 0xb4, 0x6b,
    0xd2, 0x5b, 0xf5, 0xf0, 0x59, 0x5b, 0xbe, 0x24, 0x65, 0x51, 0x41, 0x43, 0x8e, 0x7a, 0x10, 0x0b,
};
const uint8_t T2_KEY[32] = {
    0x3d, 0x40, 0x17, 0xc3, 0xe8, 0x43, 0x89, 0x5a, 0x92, 0xb7, 0x0a, 0xa7, 0x4d, 0x1b, 0x7e, 0xbc,
    0x9c, 0x98, 0x2c, 0xcf, 0x2e, 0xc4, 0x96, 0x8c, 0xc0, 0xcd, 0x55, 0xf1, 0x2a, 0xf4, 0x66, 0x0c,
};
const uint8_t T2_MESSAGE[1] = {0x72};
const uint8_t T2_SIG[64] = {
    0x92, 0xa0, 0x09, 0xa9, 0xf0, 0xd4, 0xca, 0xb8, 0x72, 0x0e, 0x82, 0x0b, 0x5f, 0x64, 0x25, 0x40,
    0xa2, 0xb2, 0x7b, 0x54, 0x16, 0x50, 0x3f, 0x8f, 0xb3, 0x76, 0x22, 0x23, 0xeb, 0xdb, 0x69, 0xda,
    0x08, 0x5a, 0xc1, 0xe4, 0x3e, 0x15, 0x99, 0x6e, 0x45, 0x8f, 0x36, 0x13, 0xd0, 0xf1, 0x1d, 0x8c,
    0x38, 0x7b, 0x2e, 0xae, 0xb4, 0x30, 0x2a, 0xee, 0xb0, 0x0d, 0x29, 0x16, 0x12, 0xbb, 0x0c, 0x00,
};
const uint8_t T3_KEY[32] = {
    0xfc, 0x51, 0xcd, 0x8e, 0x62, 0x18, 0xa1, 0xa3, 0x8d, 0xa4, 0x7e, 0xd0, 0x02, 0x30, 0xf0, 0x58,
    0x08, 0x16, 0xed, 0x13, 0xba, 0x33, 0x03, 0xac, 0x5d, 0xeb, 0x91, 0x15, 0x48, 0x90, 0x80, 0x25,
};
const uint8_t T3_MESSAGE[2] = {0xaf, 0x82};
const uint8_t T3_SIG[64] = {
    0x62, 0x91, 0xd6, 0x57, 0xde, 0xec, 0x24, 0x02, 0x48, 0x27, 0xe6, 0x9c, 0x3a, 0xbe, 0x01, 0xa3,
    0x0c, 0xe5, 0x48, 0xa2, 0x84, 0x74, 0x3a, 0x44, 0x5e, 0x36, 0x80, 0xd7, 0xdb, 0x5a, 0xc3, 0xac,
    0x18, 0xff, 0x9b, 0x53, 0x8d, 0x16, 0xf2, 0x90, 0xae, 0x67, 0xf7, 0x60, 0x98, 0x4d, 0xc6, 0x59,
    0x4a, 0x7c, 0x15, 0xe9, 0x71, 0x6e, 0xd2, 0x8d, 0xc0, 0x27, 0xbe, 0xce, 0xea, 0x1e, 0xc4, 0x0a,
};
}  // namespace

const Ed25519Vector RFC8032[RFC8032_COUNT] = {
    {"test 1", T1_KEY, nullptr, 0, T1_SIG},
    {"test 2", T2_KEY, T2_MESSAGE, sizeof T2_MESSAGE, T2_SIG},
    {"test 3", T3_KEY, T3_MESSAGE, sizeof T3_MESSAGE, T3_SIG},
};

State storageProbe(char *value, size_t cap) {
  if (!app_store::mounted()) {
    snprintf(value, cap, "not mounted");
    return State::Fail;
  }
  const size_t total = app_store::totalBytes(), used = app_store::usedBytes();
  const size_t freeKb = (total > used ? total - used : 0) / 1024;
  const vk::fileio::Ops *io = vk::fileio::ops;
  if (io == nullptr) {
    snprintf(value, cap, "no file layer");
    return State::Fail;
  }

  uint8_t written[32], read[32];
  for (size_t i = 0; i < sizeof written; ++i) written[i] = (uint8_t)(0xA5u ^ (i * 7u));
  memset(read, 0, sizeof read);
  io->makeDir("/vk");                       // succeeds if it is already there
  const char *failed = nullptr;
  if (!io->writeAll(TEMP_FILE, written, sizeof written)) failed = "write failed";
  else if (io->size(TEMP_FILE) != (long)sizeof written) failed = "wrong size";
  else if (!io->read(TEMP_FILE, 0, read, sizeof read) || memcmp(read, written, sizeof written) != 0) failed = "read differs";
  // The file goes whether or not the steps before worked.
  const bool removed = io->removeFile(TEMP_FILE) && !io->exists(TEMP_FILE);
  if (failed == nullptr && !removed) failed = "delete failed";

  if (failed != nullptr) {
    snprintf(value, cap, "%s", failed);
    return State::Fail;
  }
  snprintf(value, cap, "%luK free of %luK", (unsigned long)freeKb, (unsigned long)(total / 1024));
  return State::Ok;
}

bool joined() { return wifi_mgr::mode() == wifi_mgr::Mode::Station && wifi_mgr::connected(); }

}  // namespace selftest
